# Keil uVision project PeriodicTimer0AInts.uvprojx, settings and files
target PeriodicTimer0AInts (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PeriodicTimer0AInts
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ../inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: PeriodicTimer0AInts.c PLL.c Timer0A.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
